## hw/arm/calypso/calypso/Kconfig
```kconfig
config CALYPSO
    bool
    default y
    select ARM_V4T
    select PFLASH_CFI01
```
